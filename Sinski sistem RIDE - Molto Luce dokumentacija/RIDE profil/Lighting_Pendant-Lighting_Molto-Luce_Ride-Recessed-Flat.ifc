Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Lighting_Pendant-Lighting_Molto-Luce_Ride-Recessed-Flat.ifc
Time: 2021-11-09T14:17:11
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Ride Recessed Flat
ePset_BIMobjectScript - Length: 577 mm; CRI: CRI: >90; Color temp: - 2700K; Dimmability: Not Dimmable; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Ride Recessed Flat; SKU (BO_prodsku): Ride_Recessed_Flat; ManufacturName (BO_Manufac): Molto Luce; BrandUrl (BO_brandurl): https://www.moltoluce.com/; ProductFamily (BO_prodfam): Lighting; ProductGroup (BO_prodgroup): Pendant Lamp; ManufacturCountry (BO_mancont): Austria; DesignCountry (BO_designcont): Austria; EditionNumber (BO_edinum): 1; Width (BO_width): 35; Height (BO_height): 35; Depth (BO_depth): 35; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/molto_luce/product/Ride_Recessed_Flat; ProductDataUrl (BO_prodaturl): bimobject.com/molto_luce/product/Ride_Recessed_Flat; InstallationInstructions (BO_montins): https://www.moltoluce.com/shop/at_en/getdocument/document/?doc=675-RIDE%20RING/Montageanleitung/675-201xxxxxxxxx_MountingInstruction_Rev_10.pdf&name=675-ride%20ring/montageanleitung/675-201xxxxxxxxx_mountinginstruction_rev_10.pdf; MaterialMain (BO_mainmat): Aluminium; MaterialSecondary (BO_secmat): Acrylic; BimObjectMainCategory (BO_bomaincat): Lighting; BimObjectMainCategoryCode (BO_bomaincat_code): lighting; BimObjectCategory (BO_bocat): Pendant Lighting; BimObjectCategoryCode (BO_bocat_code): lighting-pendants; IfcClassification (BO_ifcclas): Lamp; UnspscCode (BO_unspsc): 3911; Uniclass14Code (BO_uniclass_1_4_code): JY73; Uniclass14Description (BO_uniclass_1_4_desc): Luminaires and lamps; Uniclass20Code (BO_uniclass_2_0_code): PR-49; Uniclass20Description (BO_uniclass_2_0_desc): Luminaires And Lamps; Uniclass2015Code (BO_uniclass2015_code): Pr_70_70_48; Uniclass2015Description (BO_uniclass2015_desc): Luminaires, lighting track and lighting accessories; NBSReference (BO_nbs_ref): 49; NBSReferenceDescription (BO_nbs_desc): Luminaires And Lamps; OmniClassCode (BO_omniclass_code): 23-35 45 15; OmniClassDescription (BO_omniclass_name): Lamps; MasterFormat2014Code (BO_masterformat2014_code): 26 50 00; MasterFormat2014Description (BO_masterformat2014_name): Lighting; UniFormat2Code (BO_uniformat2_code): D5020; UniFormat2Description (BO_uniformat2_name): Lighting & Branch Wiring; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA
